Commit message: Small changes to URDF and joint limits.

File: moveo_ws/src/moveo_urdf/urdf/moveo_urdf.urdf (robot description, URDF)
Before this commit: robot moveo_urdf, 14 links, 13 joints
Joints:
- joint Joint_1: axis 0 -1 0 -> 0 1 0
